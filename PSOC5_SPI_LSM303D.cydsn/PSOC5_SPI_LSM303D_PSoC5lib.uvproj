# Keil uVision project PSOC5_SPI_LSM303D_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: PSOC5_SPI_LSM303D_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h m_miso_pin_aliases.h m_miso_pin.c m_miso_pin.h m_mosi_pin_aliases.h m_mosi_pin.c m_mosi_pin.h m_sclk_pin_aliases.h m_sclk_pin.c m_sclk_pin.h SPIM.c SPIM.h SPIM_PM.c SPIM_INT.c LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h UART_1.c UART_1.h UART_1_PM.c UART_1_INT.c Clock_1.c Clock_1.h Pin_1_aliases.h Pin_1.c Pin_1.h Pin_2_aliases.h Pin_2.c Pin_2.h Pin_3_aliases.h Pin_3.c Pin_3.h Pin_4_aliases.h Pin_4.c Pin_4.h SS.c SS.h SPIM_PVT.h UART_1_BOOT.c SPIM_IntClock.c SPIM_IntClock.h Pin_5_aliases.h Pin_5.c Pin_5.h Timer_1.c Timer_1.h Timer_1_PM.c
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: PSOC5_SPI_LSM303D_PSoC5lib (library)
